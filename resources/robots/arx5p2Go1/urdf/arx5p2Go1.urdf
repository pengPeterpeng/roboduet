Commit message: move arm base to Go1 head

File: resources/robots/arx5p2Go1/urdf/arx5p2Go1.urdf (robot description, URDF)
Before this commit: robot widowGo1, 32 links, 31 joints
Joints:
- joint zarx5p2_mount: origin xyz=0.0 0 0.057 rpy=0 0 0 -> xyz=0.1881 0 0.057 rpy=0 0 0
